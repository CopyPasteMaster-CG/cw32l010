# Keil uVision project a.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: a +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\mcu_lib\inc;..\main;..\bsp;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ../start/: startup_cw32l010.s
  group mcu_lib
    ../mcu_lib/src/: cw32l010_adc.c cw32l010_atim.c cw32l010_btim.c cw32l010_crc.c cw32l010_debug.c cw32l010_digitalsign.c cw32l010_flash.c cw32l010_gpio.c cw32l010_gtim.c cw32l010_i2c.c cw32l010_iwdt.c cw32l010_lptim.c cw32l010_lvd.c cw32l010_pwr.c cw32l010_ram.c cw32l010_rtc.c cw32l010_spi.c cw32l010_sysctrl.c cw32l010_systick.c cw32l010_uart.c cw32l010_vc.c i2c_eeprom.c system_cw32l010.c
  group main
    ../main/: interrupt.c main.c
  group bsp
    ../bsp/: BSP.c BSP_LED.c BSP_RCC.c BSP_SYSTICK.c BSP_KEY.c BSP_KVM.c BSP_SWITCH.c BSP_FLASH.c BSP_UART.c
  group app
    ../app/: APP.c APP_KEY.c APP_LED.c APP_FLASH.c APP_KVM.c APP_SWITCH.c APP_UART.c
software components: CMSIS:CORE 6.1.1
